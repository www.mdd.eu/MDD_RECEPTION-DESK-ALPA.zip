Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Office-Desks-Tables_MDD_RECEPTION-DESK-ALPA-corner.ifc
Time: 2019-10-24T13:33:57
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: RECEPTION DESK ALPA corner
ePset_BIMobjectScript - Colour: White; Leg type: NG41; Desk type: ALP18L; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): RECEPTION DESK ALPA corner; SKU (BO_prodsku): alpa_corner; ManufacturName (BO_Manufac): MDD; BrandUrl (BO_brandurl): http://www.mdd.eu; ProductFamily (BO_prodfam): RECEPCION DESKS; ProductGroup (BO_prodgroup): Alpa; ManufacturCountry (BO_mancont): Poland; DesignCountry (BO_designcont): Poland; EditionNumber (BO_edinum): 1; Width (BO_width): 2514; Height (BO_height): 1100; Depth (BO_depth): 1907; Weight (BO_weight): 172.5; QR (BO_boqrurl): http://bimobject.com/mdd/product/alpa_corner; ProductDataUrl (BO_prodaturl): bimobject.com/mdd/product/alpa_corner; ProductUrl (BO_producturl): https://mdd.eu/en/reception-desks/alpa/; TechnicalDescription (BO_techcert): https://mdd.eu/wp-content/uploads/2018/02/alpa_en.pdf; MaterialMain (BO_mainmat): MFC board; MaterialSecondary (BO_secmat): Glass; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Office Desks & Tables; BimObjectCategoryCode (BO_bocat_code): furniture-office-desks-tables; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; Uniclass20Code (BO_uniclass_2_0_code): SS-35-25-65; Uniclass20Description (BO_uniclass_2_0_desc): Reception Ff&E Systems; Uniclass2015Code (BO_uniclass2015_code): Co_20_15_58; Uniclass2015Description (BO_uniclass2015_desc): Office complexes; NBSReference (BO_nbs_ref): 35-25-65; NBSReferenceDescription (BO_nbs_desc): Reception Ff&E Systems; OmniClassCode (BO_omniclass_code): 23-21 13 00; OmniClassDescription (BO_omniclass_name): Retail and Office Equipment and Furnishings; MasterFormat2014Code (BO_masterformat2014_code): 12 51 23; MasterFormat2014Description (BO_masterformat2014_name): Office Tables; UniFormat2Code (BO_uniformat2_code): E20; UniFormat2Description (BO_uniformat2_name): FURNISHINGS; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
